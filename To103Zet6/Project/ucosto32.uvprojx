# Keil uVision project ucosto32.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucosto32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\APP;..\User\BSP;..\User\uC-CPU;..\User\uC-CPU\ARM-Cortex-M3\RealView;..\User\uC-LIB;..\User\uCOS-III\Source;..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\User\BSP\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../Libraries/CMSIS/CM3/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/: core_cm3.c system_stm32f10x.c
  group USER
    ../User/: stm32f10x_it.c
  group APP
    ../User/APP/: app.c os_app_hooks.c
  group BSP
    ../User/BSP/: bsp.c
    ../User/BSP/led/: bsp_led.c
  group uC -CPU
    ../User/uC-CPU/: cpu_core.c
    ../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC-LIB
    ../User/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOS III-Source
    ../User/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS III Port
    ../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
